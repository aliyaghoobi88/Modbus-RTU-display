# Keil uVision project Modbus Display.uvprojx, settings and files
target Modbus Display (6160000::V6.16::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Modbus Display +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=4
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Library\EEprom;..\Library\Modbus\ascii;..\Library\Modbus\functions;..\Library\Modbus\include;..\Library\Modbus\port;..\Library\Modbus\rtu;..\Library\Modbus\tcp;..\Library\RTU-Display;..\Library\SSD1306-Lib;..\Library\Modbus-Handler
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Modbus
    ../Library/Modbus/tcp/: mbtcp.c
    ../Library/Modbus/ascii/: mbascii.c
    ../Library/Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Library/Modbus/port/: mt_port.c portevent.c portserial.c porttimer.c
    ../Library/Modbus/rtu/: mbcrc.c mbrtu.c
    ../Library/Modbus/: mb.c
  group MobusHandler
    ../Library/Modbus-Handler/: RtuHandler.c
  group EEprom
    ../Library/EEprom/: ee.c
  group SSD1306-lib
    ../Library/SSD1306-Lib/: fonts.c ssd1306.c
  group RTU-Display
    ../Library/RTU-Display/: rtudisplay.c
software components: CMSIS:CORE 5.5.0
